PACKAGECONFIG_append = "\
    gif \
"