RDEPENDS_${PN} += "\
    python3-pillow \
"
