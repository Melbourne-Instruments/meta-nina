RDEPENDS_packagegroup-elk-libs-basic_append = "\
    elkcpp-dev \
    elkcpp-staticdev \
"
