RDEPENDS_packagegroup-elk-applications_remove = "\
    sensei \
"

